# IAR project mcappr.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x20
  General.SCRStackSize: 16
  ICCAVR.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgm128.xcl
configuration Release (AVR)
  as the first configuration, except:
  General.SCCStackSize: 0x80
  General.SCRStackSize: 30
  group (top)
    ./: base.c base.h crc.c hist.c led.h mbsl0.c mbsl1.c mcap.c mylib.asm timeservice.c types.h zerodef.h
  group 1wire
    OneWire/: 1wire_cmd.c delay.c main.c OW.c ow_crc.c temp.c
  group 1wire/Headers
    OneWire/: 1wire.h 1wire_cmd.h delay.h LED.h main.h OW.h ow_crc.h temp.h
